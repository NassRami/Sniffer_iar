# IAR project StartupSampleQB-R5F10PPJ-TB_HotPlugin.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10PPJ RL78 - R5F10PPJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: include
  XLINK.XclFile: xcl\lnkr5f10ppj.xcl
  XLINK.XlinkExtraOptions: -h0000-17FFF
  XLINK.XlinkStackSize: 1
  group (top)
    source/: globals.c hpi_init.asm interrupt.c low_level_initialization.c main.c
