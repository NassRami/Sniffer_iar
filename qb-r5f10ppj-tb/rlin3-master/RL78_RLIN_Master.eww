<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RL78_RLIN_Master.ewp</path>
  </project>
  <batchBuild/>
</workspace>


