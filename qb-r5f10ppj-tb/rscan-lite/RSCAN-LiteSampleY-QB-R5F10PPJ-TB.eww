<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RSCAN-LiteSampleY-QB-R5F10PPJ-TB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


