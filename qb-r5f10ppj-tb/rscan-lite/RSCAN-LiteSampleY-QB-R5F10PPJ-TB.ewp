# IAR project RSCAN-LiteSampleY-QB-R5F10PPJ-TB.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10PPJ RL78 - R5F10PPJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 16384
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: include; \RSCAN_Lite; \RSCAN_Lite\include
  XLINK.XclFile: xcl\lnkr5f10ppj.xcl
  XLINK.XlinkExtraOptions: -h00D8-FCFF
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  group (top)
    source/: low_level_initialization.c main.c
  group RSCAN_Lite
    RSCAN_Lite/include/: map_rscan_irq.c map_rscan_irqbundling.c
    RSCAN_Lite/: rscan_a.c rscan_p.c
