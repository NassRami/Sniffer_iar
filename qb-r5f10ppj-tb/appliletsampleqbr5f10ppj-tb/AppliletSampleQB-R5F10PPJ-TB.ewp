# IAR project AppliletSampleQB-R5F10PPJ-TB.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F10PPJ RL78 - R5F10PPJ
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_include
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: applilet3_src\md_lnkr5f10ppj.xcl
configuration Release (RL78)
  as the first configuration, except:
  group (top)
    ./: COM-Startup
  group applilet_src
    applilet3_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_port.c r_cg_port_user.c r_cg_timer.c r_cg_timer_user.c r_cg_wdt.c r_cg_wdt_user.c r_main.c r_systeminit.c
  group COM-Startup/Src
    COM-Startup/Src/: low_level_init.c STARTUP_priv.c STARTUP_priv.h STARTUPapi.c
  group user_src
    user_source/: globals.c
